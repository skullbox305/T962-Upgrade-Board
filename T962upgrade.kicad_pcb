# Repository skullbox305/T962-Upgrade-Board

File README.md:

# T-962/T-962A controller upgrade board #

- ## Features

  - 4x MAX31850 for K Type thermocouple 
  - DS18S20 for board temperature measurement (optional)
  - USB to UART with CH340 
  - Fan control via AD0 pin or permanent on when AD0 is not connected
  - Push buttons for reset and ISP mode
  - Seperate power supplies for the digital and analog circuitry

## Firmware ##
Designed for the [T-962-improvements Firmware](https://github.com/UnifiedEngineering/T-962-improvements) by UnifiedEngineering.

## KiCad design T962upgrade.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Thermalcouple Screw Terminal; PHOENIX_1727078; MPN 691243310008
J2: 2,54mm Pin Header; PinHeader_1x05_P2.54mm_Vertical
J3: GPIO Screw Terminal; PHOENIX_1985823; MPN 1985823
R1: 4k7; R_0603_1608Metric; MPN RND1550603SAF4701T5E

Connections:
/AD0: J3.2; also elsewhere on the board
/SW_IO: J3.1, R1.2; also elsewhere on the board
/Thermocouple 1/T+: J1.2; also elsewhere on the board
/Thermocouple 1/T-: J1.1; also elsewhere on the board
/Thermocouple 2/T+: J1.4; also elsewhere on the board
/Thermocouple 2/T-: J1.3; also elsewhere on the board
/Thermocouple 3/T+: J1.6; also elsewhere on the board
/Thermocouple 3/T-: J1.5; also elsewhere on the board
/Thermocouple 4/T+: J1.8; also elsewhere on the board
/Thermocouple 4/T-: J1.7; also elsewhere on the board
/USB & Buttons & LEDs/ISP: J2.1; also elsewhere on the board
/USB & Buttons & LEDs/RX: J2.3; also elsewhere on the board
/USB & Buttons & LEDs/Reset: J2.2; also elsewhere on the board
/USB & Buttons & LEDs/TX: J2.4; also elsewhere on the board
VDD: R1.1; also elsewhere on the board
VSS: J2.5; also elsewhere on the board

Notes on the sheet:
MAX31850 Single Wire Address Selection: Address 0: AD0 + AD1 = GND Address 1: AD0 = VDDA, AD1 = GND Address 2: AD0 = GND, A1 = VDDA Address 3: AD0 + AD1 = VDDA ...

Parts:
C7: 10uF; C_0805_2012Metric; MPN CL21A106KAYNNNG
C8, C9: 0.1uF; C_0603_1608Metric; MPN CL10B104KB8NNNL
D2, D3, D4, D5: LED; LED_0603_1608Metric; MPN LS L29K-G1H2-1-Z
FB3: BLM18PG121SN1D; L_0603_1608Metric; MPN BLM18PG121SN1D
J4: USB_B_Micro; USB_Micro-B_Molex-105017-0001; MPN 105017-0001
R2, R3, R4, R5: 10K; R_0603_1608Metric; MPN AC0603JR-0710KL
R8, R9: 470R; R_0603_1608Metric; MPN RC0603JR-07470RL
SW1, SW2: Boot; SW_SPST_TL3342; MPN TL3342F160QG
U2: CH340C; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
/USB & Buttons & LEDs/ISP: R9.2; also elsewhere on the board
/USB & Buttons & LEDs/RX: D3.1 (K), U2.3 (RXD); also elsewhere on the board
/USB & Buttons & LEDs/Reset: R8.2; also elsewhere on the board
/USB & Buttons & LEDs/TX: D2.1 (K), U2.2 (TXD); also elsewhere on the board
Earth: FB3.2, J4.6 (Shield)
unnamed: C7.1, J4.1 (VBUS)
unnamed: C8.1, U2.4 (V3)
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: J4.2 (D-), U2.6 (UD-)
unnamed: J4.3 (D+), U2.5 (UD+)
unnamed: R8.1, SW1.1
unnamed: R9.1, SW2.1
VDD: C9.1, R2.1, R3.1, R4.1, U2.16 (VCC); also elsewhere on the board
VDDA: R5.1; also elsewhere on the board
VSS: C7.2, C8.2, C9.2, D4.1 (K), FB3.1, J4.5 (GND), SW1.2, SW2.2, U2.1 (GND); also elsewhere on the board
VSSA: D5.1 (K); also elsewhere on the board

Notes on the sheet:
USB to Serial
Buttons to enter Bootloader Mode
LED indicators

Parts:
C10, C13, C14, C17, C18: 10uF; C_0805_2012Metric; MPN CL21A106KAYNNNG
C11, C15: 0.1uF; C_0603_1608Metric; MPN CL10B104KB8NNNL
C12, C16: 1uF; C_0603_1608Metric; MPN CL10A105KA8NNNC
FB4, FB5: BLM18PG121SN1D; L_0603_1608Metric; MPN BLM18PG121SN1D
U3, U4: LM1117-3.3; SOT-223-3_TabPin2; MPN LM1117IMP-3.3/NOPB

Connections:
+VDC: C10.1, C11.1, C14.1, C15.1, U3.3 (VI), U4.3 (VI); also elsewhere on the board
unnamed: C16.1, C17.1, FB4.2, U4.2 (VO)
VDD: C12.1, C13.1, U3.2 (VO); also elsewhere on the board
VDDA: C18.1, FB4.1; also elsewhere on the board
VSS: C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, FB5.2, U3.1 (GND), U4.1 (GND); also elsewhere on the board
VSSA: C18.2, FB5.1; also elsewhere on the board

Notes on the sheet:
Digital Power Supply 3.3V (LM1117 LDO)
Analog Power Supply 3.3V (LM1117 LDO)
VDC is supplied by the 12V Fan Output of the main controller board

Parts:
C1, C2: DNP; C_0603_1608Metric
C3, C4: 0.01uF; C_0603_1608Metric; MPN CL10B103KB8NNNC
C5: 0.1uF; C_0603_1608Metric; MPN CL10B104KB8NNNL
C6: 1uF; C_0603_1608Metric; MPN CL10A105KA8NNNC
D1: NUP2105L; SOT-23; MPN SZNUP2105LT1G
FB1, FB2: BLM18PG121SN1D; L_0603_1608Metric; MPN BLM18PG121SN1D
U1: MAX31850KATB+; MAX31850; MPN MAX31850KATB+

Connections:
/SW_IO: U1.5 (DQ); also elsewhere on the board
/Thermocouple 1/T+: FB2.2; also elsewhere on the board
/Thermocouple 1/T-: FB1.2; also elsewhere on the board
unnamed: C1.2, C3.1, D1.2 (K), FB1.1, U1.2 (T-)
unnamed: C2.1, C3.2, D1.1 (K), FB2.1, U1.3 (T+)
VDDA: C4.1, C5.1, C6.1, U1.4 (VCC); also elsewhere on the board
VSSA: C1.1, C2.2, C4.2, C5.2, C6.2, D1.3 (A), U1.1 (GND), U1.6 (AD0), U1.7 (AD1), U1.8 (AD2), U1.9 (AD3), U1.11 (EP); also elsewhere on the board

Parts of its further copies:
C19, C20, C25, C26, C31, C32: DNP; C_0603_1608Metric
C21, C22, C27, C28, C33, C34: 0.01uF; C_0603_1608Metric; MPN CL10B103KB8NNNC
C23, C29, C35: 0.1uF; C_0603_1608Metric; MPN CL10B104KB8NNNL
C24, C30, C36: 1uF; C_0603_1608Metric; MPN CL10A105KA8NNNC
D6, D7, D8: NUP2105L; SOT-23; MPN SZNUP2105LT1G
FB6, FB7, FB8, FB9, FB10, FB11: BLM18PG121SN1D; L_0603_1608Metric; MPN BLM18PG121SN1D
U5, U6, U7: MAX31850KATB+; MAX31850; MPN MAX31850KATB+

Connections of its further copies:
/SW_IO: U5.5 (DQ), U6.5 (DQ), U7.5 (DQ); also elsewhere on the board
/Thermocouple 2/T+: FB7.2; also elsewhere on the board
/Thermocouple 2/T-: FB6.2; also elsewhere on the board
/Thermocouple 3/T+: FB9.2; also elsewhere on the board
/Thermocouple 3/T-: FB8.2; also elsewhere on the board
/Thermocouple 4/T+: FB11.2; also elsewhere on the board
/Thermocouple 4/T-: FB10.2; also elsewhere on the board
unnamed: C19.2, C21.1, D6.2 (K), FB6.1, U5.2 (T-)
unnamed: C20.1, C21.2, D6.1 (K), FB7.1, U5.3 (T+)
unnamed: C25.2, C27.1, D7.2 (K), FB8.1, U6.2 (T-)
unnamed: C26.1, C27.2, D7.1 (K), FB9.1, U6.3 (T+)
unnamed: C31.2, C33.1, D8.2 (K), FB10.1, U7.2 (T-)
unnamed: C32.1, C33.2, D8.1 (K), FB11.1, U7.3 (T+)
VDDA: C22.1, C23.1, C24.1, C28.1, C29.1, C30.1, C34.1, C35.1, C36.1, U5.4 (VCC), U5.6 (AD0), U6.4 (VCC), U6.7 (AD1), U7.4 (VCC), U7.6 (AD0), U7.7 (AD1); also elsewhere on the board
VSSA: C19.1, C20.2, C22.2, C23.2, C24.2, C25.1, C26.2, C28.2, C29.2, C30.2, C31.1, C32.2, C34.2, C35.2, C36.2, D6.3 (A), D7.3 (A), D8.3 (A), U5.1 (GND), U5.7 (AD1), U5.8 (AD2), U5.9 (AD3), U5.11 (EP), U6.1 (GND), U6.6 (AD0), U6.8 (AD2), U6.9 (AD3), U6.11 (EP), U7.1 (GND), U7.8 (AD2), U7.9 (AD3), U7.11 (EP); also elsewhere on the board

Notes on the sheet:
Thermocouple MAX21850

Parts:
C37: 0.1uF; C_0603_1608Metric; MPN CL10B104KB8NNNL
C38: 1uF; C_0603_1608Metric; MPN CL10A105KA8NNNC
U8: DS18S20; TO-92_Inline; MPN DS18S20+T&R

Connections:
/SW_IO: U8.2 (DQ); also elsewhere on the board
VDD: C37.1, C38.1, U8.3 (VDD); also elsewhere on the board
VSS: C37.2, C38.2, U8.1 (GND); also elsewhere on the board

Notes on the sheet:
PCB Temperature Sensor

Parts:
C39: 10uF; C_0805_2012Metric; MPN CL21A106KAYNNNG
D9, D10: M7; D_SMA; MPN P4SMA250A
J5: Fan In; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
J6: Fan Out; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical; MPN B2B-XH-A(LF)(SN)
Q1: 2N7002K-7; SOT-23; MPN 2N7002K-7
R10: 100k; R_0603_1608Metric; MPN RC0603JR-07100KL

Connections:
+VDC: D9.1 (K); also elsewhere on the board
/AD0: Q1.1 (G), R10.2; also elsewhere on the board
unnamed: C39.1, D9.2 (A), D10.1 (K), J5.1, J6.2
unnamed: D10.2 (A), J6.1, Q1.3 (D)
VDD: R10.1; also elsewhere on the board
VSS: C39.2, J5.2, Q1.2 (S); also elsewhere on the board

Notes on the sheet:
+ -
Out
- +
- +
Even if you don't want to use the fan control, you still need to connect the fan input to the fan output of the main controller board. This connection will supply the upgrade board with 12V. If you don't want to use it, don't connect the AD0 Pin from the main controller board. This way the system f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
System Fan Control

Board: 2 copper layers, 70.5 x 51.0 mm, 89 parts (0 on the bottom side), 41 nets.

## Commit log

2020-10-21 Bugfixes in the schematic and started the pcb layout
2020-10-21 Layout changes
2020-10-21 readme changes
2020-10-31 Finished routing
2020-11-05 small bugfixes. Added parts to bom
